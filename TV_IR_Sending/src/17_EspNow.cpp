// =============================================================================
// 17_EspNow.cpp — ESP-NOW Sender: forwards DSTV IR frames to the TV IR RX
// =============================================================================

#include <Arduino.h>
#include <esp_now.h>
#include <IRrecv.h>
#include <IRutils.h>
#include "IrLink.h"
#include "all_includes.h"

static portMUX_TYPE linkMux = portMUX_INITIALIZER_UNLOCKED;

// ── Peer state (written by WiFi-task callback, applied in EspNowMaintain) ─────
static uint8_t           rxMac[6];
static bool              rxKnown      = false;
static uint8_t           pendingMac[6];
static volatile bool     pendingPeer  = false;
static volatile uint32_t lastBeaconMs = 0;
static char              rxName[IRLINK_NAME_LEN] = "";   // RX System Name from its beacon
static bool              linkUp       = false;
static uint32_t          rxIrSent      = 0;       // from beacon
static bool              rxIrSentKnown = false;   // false = older RX without the field

// ── Counters ──────────────────────────────────────────────────────────────────
static volatile uint32_t cntForwarded = 0, cntOk = 0, cntFail = 0, cntSkipped = 0;
static uint8_t           lastFormat   = 0;
static uint64_t          lastValue    = 0;
static uint16_t          lastRawCount = 0;

static uint16_t seq             = 0;
static uint32_t lastHeartbeatMs = 0;

static void RecSetup();      // record section at the end of this file
static void RecMaintain();

// Room name sent to the RX = Settings "System Name" (cut to 15 chars).
// Copied under linkMux: the web task writes it, loop() reads it.
static char          roomName[IRLINK_NAME_LEN] = TX_ROOM_NAME;
static volatile bool heartbeatNow = false;   // announce a new name right away

static void copyRoomName(char *out) {
	portENTER_CRITICAL(&linkMux);
	memcpy(out, roomName, IRLINK_NAME_LEN);
	portEXIT_CRITICAL(&linkMux);
}

// -----------------------------------------------------------------------------
// EspNowSetRoomName — from Settings "System Name"; blank → TX_ROOM_NAME
// -----------------------------------------------------------------------------
void EspNowSetRoomName(const String &name) {
	String n = name;
	n.trim();
	if (n.isEmpty()) n = TX_ROOM_NAME;
	char buf[IRLINK_NAME_LEN];
	strlcpy(buf, n.c_str(), IRLINK_NAME_LEN);
	portENTER_CRITICAL(&linkMux);
	bool changed = strcmp(buf, roomName) != 0;
	memcpy(roomName, buf, IRLINK_NAME_LEN);
	portEXIT_CRITICAL(&linkMux);
	if (changed) heartbeatNow = true;
}

// -----------------------------------------------------------------------------
static String macToString(const uint8_t *mac) {
	char buf[18];
	snprintf(buf, sizeof(buf), "%02X:%02X:%02X:%02X:%02X:%02X",
	         mac[0], mac[1], mac[2], mac[3], mac[4], mac[5]);
	return String(buf);
}

static void fillHeader(IrLinkHeader &h, uint8_t type) {
	h.magic   = IRLINK_MAGIC;
	h.version = IRLINK_VERSION;
	h.type    = type;
}

// -----------------------------------------------------------------------------
// OnDataRecv — RX beacon and record status (WiFi task: keep it short)
// -----------------------------------------------------------------------------
static void OnRecStatus(const uint8_t *mac, const uint8_t *data, int len);   // below

static void OnDataRecv(const uint8_t *mac, const uint8_t *data, int len) {
	if (len < (int)sizeof(IrLinkHeader)) return;
	IrLinkHeader hdr;
	memcpy(&hdr, data, sizeof(hdr));
	if (hdr.magic != IRLINK_MAGIC || hdr.version != IRLINK_VERSION) return;
	if (hdr.type == PKT_REC_STATUS) { OnRecStatus(mac, data, len); return; }
	if (hdr.type != PKT_BEACON || len < (int)IRLINK_BEACON_V1_SIZE) return;

	IrLinkBeacon b = {};
	memcpy(&b, data, min((size_t)len, sizeof(b)));
	b.name[IRLINK_NAME_LEN - 1] = '';
	bool hasIrSent = len >= (int)sizeof(IrLinkBeacon);

	portENTER_CRITICAL(&linkMux);
	lastBeaconMs  = millis();
	memcpy(rxName, b.name, IRLINK_NAME_LEN);
	rxIrSent      = b.irSent;
	rxIrSentKnown = hasIrSent;
	if (!rxKnown || memcmp(mac, rxMac, 6) != 0) {
		memcpy(pendingMac, mac, 6);
		pendingPeer = true;
	}
	portEXIT_CRITICAL(&linkMux);
}

// -----------------------------------------------------------------------------
// OnDataSent — delivery result of every unicast frame to the RX
// -----------------------------------------------------------------------------
static void OnDataSent(const uint8_t *mac, esp_now_send_status_t status) {
	if (status == ESP_NOW_SEND_SUCCESS) cntOk++;
	else                                cntFail++;
}

// -----------------------------------------------------------------------------
// SetupEspNow
// -----------------------------------------------------------------------------
void SetupEspNow() {
	if (esp_now_init() != ESP_OK) {
		SaveGenReport F("ESP-NOW init FAILED");
		return;
	}
	esp_now_register_recv_cb(OnDataRecv);
	esp_now_register_send_cb(OnDataSent);
	seq = (uint16_t)esp_random();   // random start: RX drops a repeated seq as duplicate
	RecSetup();
	EspNowSetRoomName(Params->SysName);
	char name[IRLINK_NAME_LEN];
	copyRoomName(name);
	SaveGenReport("ESP-NOW ready, room '" + String(name) + "', channel " + String(WiFi.channel()));
}

// -----------------------------------------------------------------------------
// EspNowForwardIr — called from IRLoop for every accepted DSTV frame
// XMP is sent as value/bits (RX rebuilds exact timing); anything else as raw.
// -----------------------------------------------------------------------------
void EspNowForwardIr(const decode_results *r) {
	uint8_t dest[6];
	portENTER_CRITICAL(&linkMux);
	bool known = rxKnown;
	memcpy(dest, rxMac, 6);
	portEXIT_CRITICAL(&linkMux);
	if (!known) { cntSkipped++; return; }

	IrLinkIrFrame f;
	memset(&f, 0, sizeof(f));
	fillHeader(f.hdr, PKT_IR_FRAME);
	copyRoomName(f.room);
	f.seq      = ++seq;
	f.protocol = (uint16_t)r->decode_type;
	f.bits     = r->bits;
	f.value    = r->value;

	if (r->decode_type == XMP) {
		f.format = FMT_XMP;
	} else {
		uint16_t n = getCorrectedRawLength(r);
		if (n == 0 || n > IRLINK_MAX_RAW) { cntSkipped++; return; }
		uint16_t *raw = resultToRawArray(r);   // µs durations, caller frees
		if (!raw) { cntSkipped++; return; }
		memcpy(f.raw, raw, n * sizeof(uint16_t));
		delete[] raw;
		f.format   = FMT_RAW;
		f.rawCount = n;
	}

	if (esp_now_send(dest, (const uint8_t *)&f, IrLinkFrameSize(f.rawCount)) != ESP_OK) {
		cntFail++;
	}
	cntForwarded++;

	portENTER_CRITICAL(&linkMux);
	lastFormat   = f.format;
	lastValue    = f.value;
	lastRawCount = f.rawCount;
	portEXIT_CRITICAL(&linkMux);
}

// -----------------------------------------------------------------------------
// sendHeartbeat
// -----------------------------------------------------------------------------
static void sendHeartbeat() {
	IrLinkHeartbeat hb;
	memset(&hb, 0, sizeof(hb));
	fillHeader(hb.hdr, PKT_HEARTBEAT);
	copyRoomName(hb.room);
	hb.uptimeSec = millis() / 1000;
	hb.wifiRssi  = (int8_t)WiFi.RSSI();
	hb.sentOk    = cntOk;
	hb.sentFail  = cntFail;
	esp_now_send(rxMac, (const uint8_t *)&hb, sizeof(hb));
}

// -----------------------------------------------------------------------------
// EspNowMaintain — apply learned RX peer, track link state, send heartbeat
// -----------------------------------------------------------------------------
void EspNowMaintain() {
	// ── New / changed RX MAC from a beacon ────────────────────────────────────
	if (pendingPeer) {
		uint8_t newMac[6];
		portENTER_CRITICAL(&linkMux);
		memcpy(newMac, pendingMac, 6);
		pendingPeer = false;
		portEXIT_CRITICAL(&linkMux);

		if (rxKnown) esp_now_del_peer(rxMac);

		esp_now_peer_info_t peer = {};
		memcpy(peer.peer_addr, newMac, 6);
		peer.channel = 0;              // current channel = the AP's channel
		peer.ifidx   = WIFI_IF_STA;
		peer.encrypt = false;
		if (esp_now_add_peer(&peer) == ESP_OK) {
			portENTER_CRITICAL(&linkMux);
			memcpy(rxMac, newMac, 6);
			rxKnown = true;
			portEXIT_CRITICAL(&linkMux);
			SaveGenReport("ESP-NOW receiver found: " + macToString(newMac));
			lastHeartbeatMs = 0;   // announce ourselves straight away
		} else {
			SaveGenReport("ESP-NOW add peer FAILED: " + macToString(newMac));
		}
	}

	// ── Link state from beacon age ────────────────────────────────────────────
	bool up = rxKnown && (millis() - lastBeaconMs < ESPNOW_RX_LOST_MS);
	if (up != linkUp) {
		linkUp = up;
		if (up) {
			SaveGenReport F("ESP-NOW link to receiver UP");
		} else {
			SaveGenReport F("ESP-NOW link to receiver LOST");
		}
	}

	RecMaintain();

	// ── Heartbeat ─────────────────────────────────────────────────────────────
	if (rxKnown && (heartbeatNow || lastHeartbeatMs == 0 ||
	                millis() - lastHeartbeatMs >= IRLINK_HEARTBEAT_MS)) {
		heartbeatNow    = false;
		lastHeartbeatMs = millis() | 1;   // never 0 after the first send
		sendHeartbeat();
	}
}

// -----------------------------------------------------------------------------
// EspNowGetStats
// -----------------------------------------------------------------------------
EspNowStats EspNowGetStats() {
	EspNowStats s;
	portENTER_CRITICAL(&linkMux);
	s.rxKnown      = rxKnown;
	memcpy(s.rxMac, rxMac, 6);
	s.beaconAgeMs  = millis() - lastBeaconMs;
	s.lastFormat   = lastFormat;
	s.lastValue    = lastValue;
	s.lastRawCount = lastRawCount;
	memcpy(s.rxName, rxName, IRLINK_NAME_LEN);
	s.rxIrSent      = rxIrSent;
	s.rxIrSentKnown = rxIrSentKnown;
	portEXIT_CRITICAL(&linkMux);
	s.linkUp    = linkUp;
	s.forwarded = cntForwarded;
	s.sentOk    = cntOk;
	s.sentFail  = cntFail;
	s.skipped   = cntSkipped;
	return s;
}

// =============================================================================
// Recording a sequence for the RX — page /recseq (18_RecSeq.cpp)
// =============================================================================
// The RX keeps the recording; this side only sends the commands and the
// strokes captured by our TSOP, and caches the RX status for the page. While
// the RX is recording, IRLoop forwards every remote (not only DSTV) and
// also hands it to EspNowRecStroke.
// -----------------------------------------------------------------------------
#define REC_POLL_MS        1000UL    // status poll while the page is open / recording
#define REC_PAGE_OPEN_MS   3000UL    // page counts as open this long after its last poll
#define REC_STALE_MS       15000UL   // no RX status this long -> back to normal forwarding
#define REC_START_HOLD_MS  3000UL    // recording mode right after START, before the answer

static IrLinkRecStatus   recSt;                    // last status from the RX (linkMux)
static uint32_t          recStMs       = 0;        // when it arrived, 0 = never (linkMux)
static bool              recStrokeHeld = false;    // stroke sent, no RX status since (linkMux)
static uint16_t          recCmdSeq     = 0;
static volatile uint32_t recStartMs    = 0;
static volatile uint32_t recPageMs     = 0;
static uint32_t          recPollMs     = 0;
static uint16_t          recStrokeId   = 0;
static volatile uint8_t  recNote       = 0;        // 1 = last stroke too long to record
static uint8_t           myMac[6];                 // our STA MAC = ESP-NOW sender address

static void RecSetup() {
	WiFi.macAddress(myMac);
	recCmdSeq   = (uint16_t)esp_random();   // after a TX reboot: not the RX's last cmdSeq
	recStrokeId = (uint16_t)esp_random();
}

static void OnRecStatus(const uint8_t *mac, const uint8_t *data, int len) {
	if (len < (int)sizeof(IrLinkRecStatus)) return;
	portENTER_CRITICAL(&linkMux);
	if (rxKnown && memcmp(mac, rxMac, 6) == 0) {
		memcpy(&recSt, data, sizeof(recSt));
		recSt.name[sizeof(recSt.name) - 1]         = 0;
		recSt.pending[sizeof(recSt.pending) - 1]   = 0;
		recSt.lastStep[sizeof(recSt.lastStep) - 1] = 0;
		recSt.msg[sizeof(recSt.msg) - 1]           = 0;
		recStMs       = millis() | 1;
		recStrokeHeld = false;
	}
	portEXIT_CRITICAL(&linkMux);
}

// -----------------------------------------------------------------------------
// EspNowRecActive — the RX is recording a sequence controlled from here
// -----------------------------------------------------------------------------
bool EspNowRecActive() {
	uint32_t start = recStartMs;
	if (start && millis() - start < REC_START_HOLD_MS) return true;
	portENTER_CRITICAL(&linkMux);
	uint8_t  st   = recSt.state;
	uint32_t at   = recStMs;
	bool     mine = memcmp(recSt.owner, myMac, 6) == 0;   // another room's recording: stay normal
	portEXIT_CRITICAL(&linkMux);
	return at && millis() - at < REC_STALE_MS && st != RECST_IDLE && mine;
}

// -----------------------------------------------------------------------------
// EspNowRecCommand — returns the cmdSeq sent (0 = not sent, err says why)
// -----------------------------------------------------------------------------
uint16_t EspNowRecCommand(uint8_t cmd, const String &text, uint32_t delayMs, String &err) {
	uint8_t dest[6];
	portENTER_CRITICAL(&linkMux);
	bool known = rxKnown;
	memcpy(dest, rxMac, 6);
	portEXIT_CRITICAL(&linkMux);
	if (!known || !linkUp) {
		err = "Receiver not found - see the link on the STATUS page";
		return 0;
	}
	IrLinkRecCmd c;
	memset(&c, 0, sizeof(c));
	fillHeader(c.hdr, PKT_REC_CMD);
	if (cmd != RECCMD_STATUS) {
		if (++recCmdSeq == 0) recCmdSeq = 1;
		c.cmdSeq = recCmdSeq;
	}
	c.cmd     = cmd;
	c.delayMs = delayMs;
	strlcpy(c.text, text.c_str(), sizeof(c.text));
	if (esp_now_send(dest, (const uint8_t *)&c, sizeof(c)) != ESP_OK) {
		err = "Sending to the receiver failed - try again";
		return 0;
	}
	if (cmd == RECCMD_START) { recStartMs = millis() | 1; recNote = 0; }
	return cmd == RECCMD_STATUS ? 1 : c.cmdSeq;
}

static void RecMaintain() {
	bool pageOpen = recPageMs && millis() - recPageMs < REC_PAGE_OPEN_MS;
	if (!(pageOpen || EspNowRecActive()) || millis() - recPollMs < REC_POLL_MS) return;
	recPollMs = millis();
	String err;
	EspNowRecCommand(RECCMD_STATUS, "", 0, err);
}

// -----------------------------------------------------------------------------
// EspNowRecStroke — from IRLoop while recording: send the stroke to the RX.
// Only while the RX waits for a stroke; remote repeat frames are not sent.
// -----------------------------------------------------------------------------
void EspNowRecStroke(const decode_results *r) {
	uint8_t dest[6];
	portENTER_CRITICAL(&linkMux);
	bool known = rxKnown;
	memcpy(dest, rxMac, 6);
	bool waiting = recSt.state == RECST_WAIT_IR && !recStrokeHeld && memcmp(recSt.owner, myMac, 6) == 0;
	portEXIT_CRITICAL(&linkMux);
	if (!known || !waiting || r->repeat) return;

	const uint16_t kMaxRaw = IRLINK_REC_PART_RAW * IRLINK_REC_MAX_PARTS;
	if (r->overflow) { recNote = 1; return; }

	IrLinkRecStroke p;
	memset(&p, 0, sizeof(p));
	fillHeader(p.hdr, PKT_REC_STROKE);
	p.strokeId = ++recStrokeId;
	p.protocol = (uint16_t)r->decode_type;
	p.bits     = r->bits;
	p.value    = r->value;

	if (r->decode_type == XMP) {
		p.format = FMT_XMP;
		p.parts  = 1;
		esp_now_send(dest, (const uint8_t *)&p, IrLinkRecStrokeSize(0));
	} else {
		uint16_t n = getCorrectedRawLength(r);
		if (n == 0) return;
		if (n > kMaxRaw) { recNote = 1; return; }
		uint16_t *raw = resultToRawArray(r);   // µs durations, caller frees
		if (!raw) return;
		p.format   = FMT_RAW;
		p.rawTotal = n;
		p.parts    = (n + IRLINK_REC_PART_RAW - 1) / IRLINK_REC_PART_RAW;
		for (uint8_t i = 0; i < p.parts; i++) {
			uint16_t off = i * IRLINK_REC_PART_RAW;
			uint16_t cnt = min((uint16_t)IRLINK_REC_PART_RAW, (uint16_t)(n - off));
			p.part     = i;
			p.rawCount = cnt;
			memcpy(p.raw, raw + off, cnt * sizeof(uint16_t));
			esp_now_send(dest, (const uint8_t *)&p, IrLinkRecStrokeSize(cnt));
			if (i + 1 < p.parts) delay(5);   // let the ESP-NOW send queue drain
		}
		delete[] raw;
	}
	recNote = 0;
	portENTER_CRITICAL(&linkMux);
	recStrokeHeld = true;
	portEXIT_CRITICAL(&linkMux);
}

// -----------------------------------------------------------------------------
// EspNowRecJson — state for the /recseq page (each call counts as "page open")
// -----------------------------------------------------------------------------
String EspNowRecJson() {
	recPageMs = millis() | 1;
	IrLinkRecStatus st;
	char rxn[IRLINK_NAME_LEN];
	portENTER_CRITICAL(&linkMux);
	memcpy(&st, &recSt, sizeof(st));
	uint32_t at = recStMs;
	memcpy(rxn, rxName, IRLINK_NAME_LEN);
	portEXIT_CRITICAL(&linkMux);
	rxn[IRLINK_NAME_LEN - 1] = 0;
	String rxs = rxn;
	rxs.trim();

	DynamicJsonDocument doc(1024);
	doc["link"]    = linkUp;
	doc["rx"]      = rxs;
	doc["age"]     = at ? (long)(millis() - at) : -1L;
	doc["ack"]     = st.ackSeq;
	doc["ok"]      = st.ok != 0;
	doc["state"]   = (at && millis() - at < REC_STALE_MS) ? st.state : 0;
	doc["steps"]   = st.steps;
	doc["name"]    = String(st.name);
	doc["pending"] = String(st.pending);
	doc["last"]    = String(st.lastStep);
	doc["msg"]     = String(st.msg);
	doc["ip"]      = st.rxIp ? IPAddress(st.rxIp).toString() : String("");
	doc["mine"]    = memcmp(st.owner, myMac, 6) == 0;
	doc["note"]    = recNote == 1 ? "That IR stroke was too long to record - try a short press" : "";
	String out;
	serializeJson(doc, out);
	return out;
}
